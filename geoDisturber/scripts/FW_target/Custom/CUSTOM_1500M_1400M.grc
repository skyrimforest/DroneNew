options:
  parameters:
    generate_options: no_gui
    id: CUSTOM_1500M_1400M
    output_language: python
    title: CUSTOM_1500M_1400M
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: receive_para.work(START_1,END_1,START_2,END_2)[0]
  states: {}
- name: LO_feq
  id: variable
  parameters:
    value: change_sink.work(hf_function_probe,aaa, bbb, freq_a, freq_b, freq_a[0],1)[0]
  states: {}
- name: SAMP
  id: variable
  parameters:
    value: receive_para.work(START_1,END_1,START_2,END_2)[0]
  states: {}
- name: SW_feq
  id: variable
  parameters:
    value: receive_para.work(START_1,END_1,START_2,END_2)[0]
  states: {}
- name: aaa
  id: variable
  parameters:
    value: '1'
  states: {}
- name: bbb
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq_a
  id: variable
  parameters:
    value: receive_para.work(START_1,END_1,START_2,END_2)[1]
  states: {}
- name: freq_b
  id: variable
  parameters:
    value: receive_para.work(START_1,END_1,START_2,END_2)[2]
  states: {}
- name: hf_function_probe
  id: variable_function_probe
  parameters:
    block_id: hf_probe_signal
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: true_en
  id: variable
  parameters:
    value: change_sink.work(hf_function_probe,aaa, bbb, freq_a, freq_b, freq_a[0],1)[1]
  states: {}
- name: END_1
  id: parameter
  parameters:
    type: intx
    value: '1630000000'
  states: {}
- name: END_2
  id: parameter
  parameters:
    type: intx
    value: '1455000000'
  states: {}
- name: START_1
  id: parameter
  parameters:
    type: intx
    value: '1480000000'
  states: {}
- name: START_2
  id: parameter
  parameters:
    type: intx
    value: '1415000000'
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: '100'
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: change_sink
  id: epy_module
  parameters:
    source_code: |
      import time
      import threading

      #global current_channel
      current_channel = 'A'
      #global last_switch_time1
      last_switch_time1 = time.time()
      #global last_switch_time2
      last_switch_time2 = time.time()
      #global counter
      counter = 0
      first_flag = 1
      print(f"INIT.............................................")  

      def work(prob_level,enable_a, enable_b, freq_a, freq_b, temp1, temp2): 
          global current_channel, last_switch_time1, last_switch_time2, counter, first_flag, LO_freq, true_en
          if first_flag:
              LO_freq = temp1
              true_en = temp2
              first_flag = 0
          if prob_level:
              #print(f"####################param1: {LO_freq}, param2: {enable_a}, param3: {enable_b}") 
              current_time = time.time()
              #print(f"OK")  
              #print(f"param1: {current_time}")  
              #print(f"time1: {last_switch_time1}") 
              #print(f"time2: {last_switch_time2}") 
              if current_time - last_switch_time1 > 0.01:
                  if enable_a and not enable_b:
                      LO_freq = freq_a[counter]
                      counter = (counter + 1) % len(freq_a)
                      true_en = True
                  elif enable_b and not enable_a:
                      LO_freq = freq_b[counter]
                      counter = (counter + 1) % len(freq_b)
                      true_en = False
                  elif enable_a and enable_b:
                      if current_time - last_switch_time2 > 10:
                          if current_channel == 'A':
                              true_en = False
                              last_switch_time2 = current_time
                              current_channel = 'B'
                          elif current_channel == 'B':
                              true_en = True
                              last_switch_time2 = current_time
                              current_channel = 'A'
                      #print(f"param1: {current_channel}") 
                      active_freqs = freq_a if true_en else freq_b
                      #print(f"param1: {active_freqs}")  
                      if counter > len(active_freqs) - 1:
                          counter = 0
                      LO_freq = active_freqs[counter]
                      counter = (counter + 1) % len(active_freqs) 
                  last_switch_time1 = current_time
          out = [LO_freq, true_en]
          return out
  states: {}
- name: hf_probe_signal
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: '12.6'
    attenuation2: '10.6'
    bandwidth: BW
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: LO_feq
    rf_port_select: '''A'''
    samplerate: SAMP
    tx1_en: true_en
    tx2_en: not true_en
    type: fc32
    uri: uri
  states: {}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: '-SW_feq/2'
    freq_sweep: SW_feq
    len_key: '"packet_len"'
    samp_cw: '1'
    samp_down: 2**14
    samp_rate: SAMP
    samp_up: 2**14
  states: {}
- name: receive_para
  id: epy_module
  parameters:
    source_code: "\nimport math\n\ndef calculate_split_size(start, end):    \n    # 计算最小分割间隔，确保间隔小于30000000    \n    interval_length = end - start    \n    if interval_length <= 0:  \n        return 0  # 如果区间长度为0或负数，返回0作为分割间隔  \n    max_splits = math.ceil(interval_length / 30000000.0)    \n    if max_splits == 0:    \n        max_splits = 1    \n    split_size = max(1, interval_length // max_splits)  # 确保分割间隔至少为1  \n    return split_size\n\n\n\ndef work(A, B, C, D):    \n    # 检查参数是否合法    \n    if not (0 <= A <= B) or not (0 <= C <= D):    \n        print(\"A, B, C, D必须满足条件：0 <= A <= B 且 0 <= C <= D\")    \n        return None, None    \n    \n    # 计算两个区间的最小分割间隔  \n    split_size_AB = calculate_split_size(A, B)  \n    split_size_CD = calculate_split_size(C, D)  \n  \n    # 取两个间隔中的较大值作为统一的间隔大小  \n    unified_split_size = max(split_size_AB, split_size_CD, 1000000)  \n  \n    # 划分区间(A, B)  \n    centers_AB = []  \n    if B-A < unified_split_size:\n        current_position = (A + B) / 2\n        centers_AB.append(int(current_position)) \n    else:\n        current_position = A + unified_split_size / 2  \n        while current_position < B:  \n            centers_AB.append(int(current_position))  \n            current_position += unified_split_size  \n        if centers_AB[-1] > B:  \n            centers_AB[-1] = B \n  \n    # 最后一个中心值可能需要微调以确保它落在区间内  \n    #if centers_AB and centers_AB[-1] > B - unified_split_size / 2:  \n    #    centers_AB[-1] = B  \n  \n    # 划分区间(C, D)  \n    centers_CD = []  \n    if D-C < unified_split_size:\n        current_position = (C + D) / 2\n        centers_CD.append(int(current_position)) \n    else:\n        current_position = C + unified_split_size / 2  \n        while current_position < D:  \n            centers_CD.append(int(current_position))  \n            current_position += unified_split_size  \n        if centers_CD[-1] > D:  \n            centers_CD[-1] = D \n  \n    # 最后一个中心值可能需要微调以确保它落在区间内  \n    #if centers_CD and centers_CD[-1] > D - unified_split_size / 2:  \n    #    centers_CD[-1] = D   \n \n    out = [unified_split_size, centers_AB, centers_CD]\n    return out\n"
  states: {}
- name: uri
  id: parameter
  parameters:
    type: str
    value: 192.168.1.11
  states: {}

connections:
- [analog_sig_source_x_1, '0', hf_probe_signal, '0']
- [radar_signal_generator_fmcw_c_0, '0', iio_fmcomms2_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
