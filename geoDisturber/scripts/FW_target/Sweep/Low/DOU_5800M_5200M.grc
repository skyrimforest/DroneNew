options:
  parameters:
    generate_options: no_gui
    id: DOU_5800M_5200M
    output_language: python
    title: DOU_5800M_5200M
  states: {}

blocks:
- name: BW
  id: variable
  parameters:
    value: '30000000'
  states: {}
- name: LO_feq
  id: variable
  parameters:
    value: change_sink.work(hf_function_probe,aaa, bbb, freq_a, freq_b, atten_a, atten_b, 5727000000,1,4.2)[0]
  states: {}
- name: SAMP
  id: variable
  parameters:
    value: '26000000'
  states: {}
- name: SW_feq
  id: variable
  parameters:
    value: '26000000'
  states: {}
- name: aaa
  id: variable
  parameters:
    value: '1'
  states: {}
- name: atten
  id: variable
  parameters:
    value: change_sink.work(hf_function_probe,aaa, bbb, freq_a, freq_b, atten_a, atten_b, 5727000000,1,4.2)[2]
  states: {}
- name: atten_a
  id: variable
  parameters:
    value: 4.2,4.2,3.5,3,3,3
  states: {}
- name: atten_b
  id: variable
  parameters:
    value: 12.5,12.5,12.7,12.3,12.7,13.2,12.6,12.6
  states: {}
- name: bbb
  id: variable
  parameters:
    value: '1'
  states: {}
- name: freq_a
  id: variable
  parameters:
    value: 5727000000,5753000000,5779000000,5805000000,5831000000,5857000000
  states: {}
- name: freq_b
  id: variable
  parameters:
    value: 5159000000,5185000000,5211000000,5237000000,5263000000,5289000000,5315000000,5341000000
  states: {}
- name: hf_function_probe
  id: variable_function_probe
  parameters:
    block_id: hf_probe_signal
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: loss
  id: variable
  parameters:
    value: '4.5'
  states: {}
- name: true_en
  id: variable
  parameters:
    value: change_sink.work(hf_function_probe,aaa, bbb, freq_a, freq_b, atten_a, atten_b, 5727000000,1,4.2)[1]
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: '10'
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: change_sink
  id: epy_module
  parameters:
    source_code: |
      import time
      import threading


      current_channel = 'A'
      last_switch_time1 = time.time()
      last_switch_time2 = time.time()
      counter = 0
      first_flag = 1
      print(f"INIT.............................................")  

      def work(prob_level,enable_a, enable_b, freq_a, freq_b, atten_a, atten_b, temp1, temp2, temp3): 
          global current_channel, last_switch_time1, last_switch_time2, counter, first_flag, LO_freq, true_en, atten
          if first_flag:
              LO_freq = temp1
              true_en = temp2
              atten = temp3
              first_flag = 0
          if prob_level:
              current_time = time.time()
              if current_time - last_switch_time1 > 0.1:
                  if enable_a and not enable_b:
                      LO_freq = freq_a[counter]
                      atten = atten_a[counter]
                      counter = (counter + 1) % len(freq_a)
                      true_en = True
                  elif enable_b and not enable_a:
                      LO_freq = freq_b[counter]
                      atten = atten_b[counter]
                      counter = (counter + 1) % len(freq_b)
                      true_en = False
                  elif enable_a and enable_b:
                      if current_time - last_switch_time2 > 10:
                          if current_channel == 'A':
                              true_en = False
                              last_switch_time2 = current_time
                              current_channel = 'B'
                          elif current_channel == 'B':
                              true_en = True
                              last_switch_time2 = current_time
                              current_channel = 'A'
                      active_freqs = freq_a if true_en else freq_b
                      active_atten = atten_a if true_en else atten_b
                      if counter > len(active_freqs) - 1:
                          counter = 0
                      LO_freq = active_freqs[counter]
                      atten = active_atten[counter]
                      counter = (counter + 1) % len(active_freqs) 
                  last_switch_time1 = current_time
          out = [LO_freq, true_en, atten]
          return out
  states: {}
- name: hf_probe_signal
  id: blocks_probe_signal_x
  parameters:
    type: complex
  states: {}
- name: iio_fmcomms2_sink_0
  id: iio_fmcomms2_sink
  parameters:
    attenuation1: atten+loss
    attenuation2: atten+loss
    bandwidth: BW
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: LO_feq
    rf_port_select: '''A'''
    samplerate: SAMP
    tx1_en: true_en
    tx2_en: not true_en
    type: fc32
    uri: uri
  states: {}
- name: radar_signal_generator_fmcw_c_0
  id: radar_signal_generator_fmcw_c
  parameters:
    amplitude: '1'
    freq_cw: '-SW_feq/2'
    freq_sweep: SW_feq
    len_key: '"packet_len"'
    samp_cw: '1'
    samp_down: 2**14
    samp_rate: SAMP
    samp_up: 2**14
  states: {}
- name: uri
  id: parameter
  parameters:
    type: str
    value: 192.168.1.12
  states: {}

connections:
- [analog_sig_source_x_1, '0', hf_probe_signal, '0']
- [radar_signal_generator_fmcw_c_0, '0', iio_fmcomms2_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
